Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-09-05T15:32:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 05 15:32:20 2022 * Host: CHTSW00749 * Database: C:\Users\40901979\AppData\Local\Temp\{A4BA5CAD-18AE-4C39-BEE3-A309F7DFE3E1}\ifc * Database version: 5507 * Database creation date: Mon Sep 05 15:32:17 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 05 15:32:18 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 05 15:32:18 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (mm)
Level 01 - B.O. Footing | Level 01 - B.O. Footing | -3048
Level 1 | Level 1 | 0

# IfcBuildingElementProxy: CTXBG2914(Grill, CTXBG2914(Grill:CTXBG2914(Grill:6979875
In: Level 01 - B.O. Footing
Type - Material: Black(BH), Stainless Steel
Pset_BuildingElementProxyCommon - Reference: CTXBG2914(Grill

# IfcBuildingElementProxy: LKDD, LKDD(Drain):LKDD:6979876
In: Level 01 - B.O. Footing
Type - Material: Stainless Steel
Pset_BuildingElementProxyCommon - Reference: LKDD

# IfcFlowTerminal: EFRU311610TFLC, Elkay_Sinks_Crosstown_Sink-Kits-Undermount_Bowls1:EFRU311610TFLC:6979872
In: Level 1
Type - Material: Black, 304 Stainless Steel
Pset_ElectricalDeviceCommon - IP_Code: n/a; InsulationStandardClass: n/a; PhaseReference: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Elkay.com
Pset_DistributionFlowElementCommon - Reference: EFRU311610TFLC
